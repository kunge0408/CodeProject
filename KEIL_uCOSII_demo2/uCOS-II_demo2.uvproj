# Keil uVision project uCOS-II_demo2.uvproj, settings and files
target FL2440 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: uCOS-II_demo2 +hex
  AfterMake: E:\Keil\ARM\BIN40\fromelf.exe --bin -o ./OutPutfiles/uCOS-II_demo2.bin ./OutPutfiles/uCOS-II_demo2.axf
  c flags: Optim=1
  c include: .\CommonFiles\FL2440_BSP\2440BSP_INC;.\CommonFiles\uCOS-II\uCOS-II_BSP;.\CommonFiles\uCOS-II\uCoS-II_SRC;.\App_Main\App_INC;.\CommonFiles\uCOS-II\uCOS-II_BSP;.\Drivers\LED_test\LED_test_INC
  asm include: .\CommonFiles\FL2440_BSP\2440BSP_INC
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x30000000 size 0x2000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  memory RVCT10: RAM 0x48000000 size 0x18000000
  scatter file: .\ScatterFlies\uCOS-II_demo.sct
  link misc: --entry __ENTRY
  group FL2440_BSP
    ./CommonFiles/FL2440_BSP/2440BSP_SRC/: 2440_init.s
  group uCOS-II_BSP
    ./CommonFiles/uCOS-II/uCOS-II_BSP/: Os_cpu_c.c Os_cpu_a.s os_timer4_c.c
  group uCOS-II_SRC
    ./CommonFiles/uCOS-II/uCoS-II_SRC/: os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_core.c
  group Application
    ./App_Main/App_SRC/: App_Main.c
  group Drivers
    ./Drivers/LED_test/LED_test_SRC/: LED_test.c
