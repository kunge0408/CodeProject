# Keil uVision project led.uvproj, settings and files
target 2440Led (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: led
  AfterMake: "E:\Keil\ARM\BIN40\fromelf.exe  " --bin -o @p.bin @p.axf
  c include: ..\Led_keil
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x30000000 size 0x2000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\led.sct
  group user
    ./: led.c Init.s LCD.c uart.c xyx_320_240.c bmp.c
